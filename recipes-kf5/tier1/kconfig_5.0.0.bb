require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "8028563bd3133c2b5ca2a33bc422c155266dba23"
PV = "5.0.0"
