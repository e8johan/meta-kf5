require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "caf58500bf43a0e4fb046500e1ac3ad56234658c"
PV = "5.0.0"
