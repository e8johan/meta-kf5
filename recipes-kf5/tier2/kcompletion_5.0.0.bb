require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "28121d01a59e463e5b1110259e6bd0f17e48f57b"
PV = "5.0.0"
